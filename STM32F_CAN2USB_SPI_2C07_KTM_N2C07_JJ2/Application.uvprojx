# Keil uVision project Application.uvprojx, settings and files
target Application (6220000::V6.22::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Application
  AfterMake: fromelf --bin --output ./Output/Application.bin ./Output/Application.axf
  c flags: uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F401xC,USB_MODULE
  c include: .\SourceCode\Inc;.\Driver\CMSIS\Inc;.\Driver\STM32F4xx_HAL_Driver\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc;C:\Keil_v540\ARM\PACK\ARM\CMSIS\6.1.0\CMSIS\Core\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.7.0\CMSIS\Include;.\uip;.\uip\webserver;.\app\inc;.\app\webserver
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Driver/CMSIS
    ./Driver/CMSIS/Src/: startup_stm32f401xc.s
  group Driver/STM32F4xx_HAL_Driver
    ./Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Middlewares/STM32_USBD_Library/Core
    ./Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_USBD_Library/HID
    ./Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group SourceCode
    ./SourceCode/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c usbd_conf.c usbd_desc.c ADES_BATTERY.c ADES_GLOBAL_VAR.c ADES_HARDWARE_FUNCTION.c ADES_LIB.c ADES_TICK_TASK.c ADES_USB_PROCESS.c ADES_EXE_FUNCTION.c CANSPI2.c MCP25152.c CANSPI1.c MCP25151.c led.c
  group UIP
    ./uip/: psock.c tapdev.c timer.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c System_Init.c clock-arch.c ipscan_generation.c uip_init.c app_call.c dhcpc.c resolv.c DM9051115.c uip115.c
  group app
    ./app/webserver/: httpd-cgi.c httpd-fs.c http-strings.c web_led.c httpd115.c
